# Keil uVision project Application.uvprojx, settings and files
target Application (6220000::V6.22::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Application +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\core;..\core\APP;..\core\CAN Bus;..\core\Common_Functions;..\core\MCU;..\core\MCU\STM32F4;..\core\Task Manager;..\core\TypeDefs;..\core\MCU\STM32F4;..\core\APP\Control_Unit;..\core\APP\Control_Unit\Control_Unit_Selection;..\core\APP\Control_Unit\Control_Unit_Selection\Front Control Unit;..\core\APP\Control_Unit\Control_Unit_Selection\Rear Control Unit;..\core\APP\Control_Unit\Control_Unit_Selection\Rear Control Unit Power Distribution;..\core\APP\Control_Unit\Control_Unit_Selection\SDC Charger;..\core\APP\Control_Unit\Control_Unit_Selection\Accu Master;..\core\MCU\Simulated_Eeprom
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../Core/APP/: main.c
  group APP/Control_Unit
    ../core/APP/Control_Unit/: Control_Unit.h Control_Unit.c
  group APP/Control_Unit/Control_Unit_Selection
    ../core/APP/Control_Unit/Control_Unit_Selection/: Control_Unit_Selection.h
  group APP/Control_Unit/Control_Unit_Selection/Rear_Control_Unit
    ../core/APP/Control_Unit/Control_Unit_Selection/Rear Control Unit/: Rear_Control_Unit.c Rear_Control_Unit.h
  group APP/Control_Unit/Control_Unit_Selection/Rear_Control_Unit_Power_Distribution
    ../core/APP/Control_Unit/Control_Unit_Selection/Rear Control Unit Power Distribution/: Rear_Control_Unit_Power_Distribution.c Rear_Control_Unit_Power_Distribution.h
  group APP/Control_Unit/Control_Unit_Selection/Front_Control_Unit
    ../core/APP/Control_Unit/Control_Unit_Selection/Front Control Unit/: Front_Control_Unit.c Front_Control_Unit.h
  group APP/Control_Unit/Control_Unit_Selection/SDC_Charger
    ../core/APP/Control_Unit/Control_Unit_Selection/SDC Charger/: SDC_Charger.h SDC_Charger.c
  group APP/Control_Unit/Control_Unit_Selection/Accu_Master
    ../core/APP/Control_Unit/Control_Unit_Selection/Accu Master/: Accu_Master_Control_Unit.c Accu_Master_Control_Unit.h
  group CAN_Bus
    ../Core/CAN Bus/: Can_Bus.c Can_Bus.h
  group Typedefs
    ../Core/TypeDefs/: TypeDefs.h
  group Common_Functions
    ../Core/Common_Functions/: Common_Functions.c Common_Functions.h
  group MCU
    ../Core/MCU/: MCU.c MCU.h
  group MCU/STM32F4
    ../Core/MCU/STM32F4/: stm32f4xx_hal_msp.c stm32f4xx_it.c STM32F4.h STM32F4.c
  group MCU/STM32F4/DRIVERS/CMSIS
    ../Core/MCU/STM32F4/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group MCU/STM32F4/DRIVERS
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_iwdg.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_iwdg.h
